options:
  parameters:
    generate_options: qt_gui
    id: hmw1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: 100e6
    stop: '100'
    value: '50'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 97.9e6
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: 96.5e6
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200k
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1.4e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480k
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: 48 khz
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75k
    decim: '140'
    gain: '1'
    samp_rate: 8e6
    type: fir_filter_ccf
    width: 25k
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '40'
    freq0: 97.6e6
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '32'
    sample_rate: 8e6
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 8e6
    fc: 97.9e6
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: 8e6
    fc: 96.5e6
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
